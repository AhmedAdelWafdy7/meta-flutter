DEPENDS:remove = "dconf"
RDEPENDS:${PN}:remove = "dconf"